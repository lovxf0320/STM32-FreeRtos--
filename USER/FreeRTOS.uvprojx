# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FreeRTOS +hex
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\FreeRTOS;..\CORE;..\FreeRTOS\include;..\FreeRTOS\portable;..\FreeRTOS\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
